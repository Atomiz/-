# Keil uVision project Template.uvprojx, settings and files
target Template (6060000::V6.6::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ST32F10X_HD
  c include: ..\USER;..\FWLIB\inc;..\FWLIB\src;..\CMSIS;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startcode
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group user
    ./: stm32f10x_it.c main.c
  group FWlib
    ../FWLIB/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group APP
    ../APP/: DMA.c USART.c SysTick.c led.c
software components: CMSIS:CORE 5.0.1
